## package/mtfwd/src/Kconfig
```kconfig
config MTFWD_SUPPORT
	tristate "MT Forward support."
	default m
	---help---
		if you want multi-backhaul work, you must enable this option.
```
